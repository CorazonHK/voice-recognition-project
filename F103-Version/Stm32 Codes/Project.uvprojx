# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,ARM_MATH_CM3,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: .\Start;.\Library;.\User;.\System;.\Hardware;..\ARM\PACK\ARM\CMSIS\5.0.1\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: startup_stm32f10x_md.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Library
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group System
    ./System/: Delay.c Delay.h
  group Hardware
    ./Hardware/: OLED.c OLED.h OLED_Font.h AD.c AD.h MyDMA.c MyDMA.h usart.c usart.h mfcc.c mfcc.h
  group User
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group DSP_Source
    ../ARM/PACK/ARM/CMSIS/5.0.1/CMSIS/DSP_Lib/Source/TransformFunctions/: arm_cfft_f32.c arm_cfft_radix2_f32.c arm_cfft_radix2_init_f32.c arm_cfft_radix4_f32.c arm_cfft_radix4_init_f32.c arm_cfft_radix8_f32.c arm_dct4_f32.c arm_dct4_init_f32.c arm_rfft_f32.c arm_rfft_fast_f32.c arm_rfft_fast_init_f32.c arm_rfft_init_f32.c arm_bitreversal.c
    ../ARM/PACK/ARM/CMSIS/5.0.1/CMSIS/DSP_Lib/Source/FastMathFunctions/: arm_cos_f32.c arm_sin_f32.c
    ../ARM/PACK/ARM/CMSIS/5.0.1/CMSIS/DSP_Lib/Source/CommonTables/: arm_common_tables.c
    ../ARM/PACK/ARM/CMSIS/5.0.1/CMSIS/DSP_Lib/Source/SupportFunctions/: arm_copy_f32.c arm_copy_q7.c arm_fill_f32.c arm_fill_q7.c arm_float_to_q7.c arm_q7_to_float.c
    ../ARM/PACK/ARM/CMSIS/5.0.1/CMSIS/DSP_Lib/Source/ComplexMathFunctions/: arm_cmplx_dot_prod_f32.c arm_cmplx_mult_cmplx_f32.c
    ../ARM/PACK/ARM/CMSIS/5.0.1/CMSIS/DSP_Lib/Source/BasicMathFunctions/: arm_mult_f32.c arm_scale_f32.c
    ./: arm_bitreversal_fix.c
